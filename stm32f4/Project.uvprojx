# Keil uVision project Project.uvprojx, settings and files
target STM32F4_Robocon (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project.hex +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c misc: --C99
  c include: .\Libraries\CMSIS\Device\ST\STM32F4xx\Include\;.\Libraries\STM32F4xx_StdPeriph_Driver\inc\;.\Libraries\STM32F4xx_StdPeriph_Driver;.\;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group STM32F4xx_StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/: stm32f4xx_it.c
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MDK-ARM
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Doc
    ./Libraries/STM32F4xx_StdPeriph_Driver/: readme.txt
  group MAIN_SOURCE
    ./src/: main.c approx_math.c led.c ticks.c tft_display.c button.c pump.c tm_stm32f4_dma.c tm_stm32f4_fonts.c tm_stm32f4_gpio.c tm_stm32f4_ili9341.c tm_stm32f4_spi.c tm_stm32f4_spi_dma.c I2C.c stepper_motor.c OV9655.c tm_stm32f4_delay.c tm_stm32f4_timer_properties.c tm_stm32f4_fatfs.c ff.c diskio.c unicode.c syscall.c fatfs_sd_sdio.c image_processing.c usart.c
    ./inc/: OV9655.h tm_stm32f4_delay.h ffconf.h integer.h ff.h usart.h
software components: CMSIS:CORE 4.1.0
